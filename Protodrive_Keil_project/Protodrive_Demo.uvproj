# Keil uVision project Protodrive_Demo.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Protodrive_Demo
  AfterMake: fromelf --bin -o build\Protodrive_Demo_LPC1768.bin build\Protodrive_Demo.axf
  c flags: Optim=3
  c define: TARGET_LPC1768, NDEBUG, TOOLCHAIN_ARM, __CMSIS_RTOS, __CORTEX_M3
  c misc: --gnu
  c include: .;  mbed;  mbed/LPC1768;  mbed/LPC1768/ARM;  RPCInterface;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  link misc: mbed/LPC1768/ARM/sys.o
                 
                mbed/LPC1768/ARM/cmsis_nvic.o
                 
                mbed/LPC1768/ARM/system_LPC17xx.o
                 
                mbed/LPC1768/ARM/core_cm3.o
                 
                mbed/LPC1768/ARM/startup_LPC17xx.o
                 
                mbed/LPC1768/ARM/capi.ar
                 
                mbed/LPC1768/ARM/mbed.ar
  group src
    ./: main.cpp
    ./RPCInterface/: RPCFunction.cpp SerialRPCInterface.cpp
